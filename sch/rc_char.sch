** sch_path: sch/rc_char.sch
**.subckt rc_char Vin ref Vout
*.ipin Vin
*.iopin ref
*.opin Vout
R1 Vin Vout 10k m=1
C1 Vout ref 10p m=1
**.ends
.end
